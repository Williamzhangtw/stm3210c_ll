# Keil uVision project Project.uvprojx, settings and files
target STM3210C-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F107xC,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ..\Inc;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Example/MDK-ARM
    ./: startup_stm32f107xc.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f1xx_it.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_exti.c stm32f1xx_ll_tim.c stm32f1xx_ll_adc.c stm32f1xx_ll_usart.c stm32f1xx_ll_crc.c stm32f1xx_ll_dma.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rtc.c stm32f1xx_ll_dac.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_utils.c
software components: CMSIS:CORE 4.3.0
